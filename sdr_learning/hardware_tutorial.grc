options:
  parameters:
    author: opensourcesdr
    generate_options: qt_gui
    id: hardware_tutorial
    output_language: python
    title: hardware_tutorial
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0.00384'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.07'
    step: 200e3
    stop: 6e6
    value: '0.1021'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0.1021'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [qtgui_sink_x_0, freq, osmosdr_source_0, command]

metadata:
  file_format: 1
